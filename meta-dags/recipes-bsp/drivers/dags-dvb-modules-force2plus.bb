require dags-dvb-modules-7362.inc
